# Keil uVision project nucleo_f413zh_game.uvprojx, settings and files
target NUCLEO_F413ZH_GAME (5060750::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F413ZH STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x08000000-0x0817FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: nucleo_f413zh_game +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F413xx
  c misc: --split_sections
  c include: ../Core/Inc;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;../Drivers/STM32F4xx_HAL_Driver/Inc;../Game/Inc;../../game/generated
  library: MicroLIB
  memory RVCT4: ROM 0x08000000 size 0x180000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\STM32F413ZH.sct
  group Application
    ../Game/Src/: main_game.c
    ../Core/Src/: gpio.c usart.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group CMSIS
    ../Core/Src/: system_stm32f4xx.c
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f413xx.s
  group STM32 HAL
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_uart.c
  group Game
    ../Game/Src/: game_engine.c game_protocol.c game_link.c
software components: CMSIS:CORE 5.3.0
